# Keil uVision project fmeter.uvprojx, settings and files
target Liquid (6190000::V6.19::ARMCLANG)
  device: HC32L196MCTA HDSC
  pack: HDSC.HC32L19x.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: liquid +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: MD_MEASURE_TYPE=MD_LIQUID
  c include: .;.\common;.\user;.\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group common
    ./common/: interrupts_hc32l19x.c system_hc32l19x.c
    ./: startup_hc32l19x.s
  group driver
    ./driver/src/: ddl.c sysctrl.c lptim.c lpm.c gpio.c wdt.c lpuart.c lvd.c reset.c rtc.c lcd.c adc.c bgr.c uart.c pcnt.c i2c.c bt.c
  group user
    ./user/: main.c 24cxx.c adx.c device.c irc.c modbus.c net.c protocol.c r_cg_sau.c r_cg_sau_user.c system.c collector.c sht4x.c sw_i2c.c hum.c hum_gas.c ertc.c etemp.c epress.c elora.c
target Gases (6190000::V6.19::ARMCLANG)
  device: HC32L196MCTA HDSC
  pack: HDSC.HC32L19x.1.1.0
  cpu: as above
  output: Gases +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: MD_MEASURE_TYPE=MD_GASES,MD_PRESS_SENSOR=MD_PRESS_SENSOR_V0
  c include: .;common;user;driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.6.0
